# Keil uVision project 5182LockProject.uvprojx, settings and files
target nrf5182 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: 51822FingerPwd +hex
  c flags: oTime=1 uC99=1 wLevel=2
  c define: BOARD_PCA10001 NRF51,DEBUG_NRF_USER, BLE_STACK_SUPPORT_REQD
  c include: ..;include;include\app_common;include\ble;include\ble\ble_services;include\s110;include\sd_common;include\cipher;include\basal;include\rtc;include\spi;include\i2c;include\module\storage;include\module\devices;include\module\light;include\module\serial;include\module\timer;include\module\tools;include\module\bluetooth;include\module\buttons;include\module\mkey;include\module\control;include\module\log;include\module\rtc;include\module\skey;include\module\battery;include\module\voice;include\module\gpio;include\module\alarm;include\module\motor;include\module\system;include\module\wifi;include\module\finger;include\module\touch
  memory RVCT4: ROM 0x16000 size 0x26000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group src
    ./src/: main.c hs_event.c main_task.c
  group services
    ./src/services/: ble_nus.c ble_srv_common.c
  group libraries
    ./src/libraries/ble/: ble_advdata.c ble_conn_params.c ble_dis.c ble_bas.c
    ./src/libraries/nrf_ecb/: nrf_ecb.c
    ./src/libraries/sd_common/: softdevice_handler.c
    ./src/libraries/app_common/: app_timer.c pstorage.c crc16.c
    ./src/libraries/cipher/: aes_decrypt.c
    ./src/libraries/i2c/: lib_i2c.c
    ./src/libraries/i2c/twi_master/: twi_sw_master.c twi_hw_master.c
    ./src/libraries/battery/: battery.c
    ./src/libraries/rtc/: lib_rtc.c
    ./src/libraries/spi/: spi_master.c lib_spi.c
  group module
    ./src/modules/storage/: hs_storage.c
    ./src/modules/light/: hs_light.c
    ./src/modules/timer/: hs_timers.c
    ./src/modules/serial/: hs_uart.c
    ./src/modules/tools/: hs_tools.c hs_aes_cipher.c
    ./src/modules/bluetooth/: hs_ble_common.c hs_ble_adv.c hs_ble_character.c
    ./src/modules/buttons/: hs_buttons.c
    ./src/modules/mkey/: hs_mkey.c
    ./src/modules/control/: hs_near_control_common.c hs_near_control_core.c
    ./src/modules/log/: hs_log.c
    ./src/modules/rtc/: hs_rtc.c
    ./src/modules/skey/: hs_skey.c
    ./src/modules/battery/: hs_battery.c
    ./src/modules/voice/: hs_voice.c
    ./src/modules/gpio/: hs_gpio.c
    ./src/modules/alarm/: hs_alarm.c
    ./src/modules/system/: hs_system.c
    ./src/modules/motor/: hs_motor.c
    ./src/modules/finger/: hs_finger.c hs_finger_addie.c hs_finger_beg511.c
    ./src/modules/touch/: hs_touch.c hs_touch_tty6952.c hs_touch_button.c
  group ::Device
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
software components: CMSIS:CORE 4.1.0, Device:Startup 7.1.0
