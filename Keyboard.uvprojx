# Keil uVision project Keyboard.uvprojx, settings and files
target Keyboard (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Keyboard +hex
  c flags: oTime=1 uC99=1 wLevel=2
  c define: BOARD_PCA10001 NRF51,DEBUG_NRF_USER, BLE_STACK_SUPPORT_REQD
  c include: code\application\include;code\application\include\module\boards;code\application\include\module\external;code\application\include\module\tools;code\application\include\basal;code\application\include\app_common;code\application\include\sd_common;code\application\include\ble;code\application\include\s110;code\application\include\ble\ble_services;code\application\include\ble\device_manager;code\application\include\module\external\touch;code\application\include\cipher
  memory RVCT4: ROM 0x16000 size 0x26000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group main
    ./code/application/source/: main.c wy_event.c
  group application
    ./code/application/source/modules/boards/: wy_uart.c wy_timers.c wy_system.c wy_storage.c wy_gpio.c wy_control_core.c wy_control_common.c wy_ble_common.c wy_ble_character.c wy_ble_adv.c wy_battery.c
    ./code/application/source/modules/external/: wy_alarm.c wy_light.c
    ./code/application/source/modules/external/touch/: wy_touch.c wy_touch_tty6952.c
    ./code/application/source/modules/tools/: wy_aes_cipher.c wy_tools.c
  group service
    ./code/application/source/libraries/sd_common/: softdevice_handler.c
    ./code/application/source/libraries/nrf_ecb/: nrf_ecb.c
    ./code/application/source/libraries/i2c/: lib_i2c.c
    ./code/application/source/services/: ble_nus.c ble_srv_common.c
    ./code/application/source/libraries/app_common/: crc16.c pstorage.c app_timer.c
    ./code/application/source/libraries/ble/: ble_advdata.c ble_conn_params.c ble_bas.c ble_dis.c
    ./code/application/source/libraries/cipher/: aes_decrypt.c
    ./code/application/source/libraries/i2c/twi_master/: twi_hw_master.c
    ./code/application/source/libraries/battery/: battery.c
software components: CMSIS:CORE 4.1.0, Device:Startup 7.1.0
